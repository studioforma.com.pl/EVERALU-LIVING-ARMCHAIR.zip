Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Ever Alu - Living Armchair - ver4.ifc
Time: 2025-11-27T14:50:41
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (9)
Name
 | Ever Alu - Living Armchair_0 - ObjectType: SketchupGroup
 | Ever Alu - Living Armchair_1 - ObjectType: SketchupGroup
 | Ever Alu - Living Armchair_2 - ObjectType: SketchupGroup
 | Ever Alu - Living Armchair_3 - ObjectType: SketchupGroup
 | Ever Alu - Living Armchair_4 - ObjectType: SketchupGroup
 | Ever Alu - Living Armchair_5 - ObjectType: SketchupGroup
 | Ever Alu - Living Armchair_6 - ObjectType: SketchupGroup
 | Ever Alu - Living Armchair_7 - ObjectType: SketchupGroup
 | Ever Alu - Living Armchair_8 - ObjectType: SketchupGroup
